# Keil uVision project my_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\CMSIS\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\drivers\dev_led;..\drivers\dev_usart;..\drivers\dev_systick;..\drivers\dev_sg90;..\drivers\dev_beep;..\drivers\dev_adc;..\drivers\dev_dma;..\drivers\dev_iic;..\drivers\dev_key;..\drivers\dev_exti;..\drivers\dev_seg;..\drivers\dev_sht20;..\drivers\dev_time;..\drivers\dev_spi;..\drivers\drv_oled;..\drivers\drv_pd333;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group apps
    ../apps/: main.c stm32f4xx_it.c
  group dirvers
    ../drivers/dev_led/: led.c
    ../drivers/dev_systick/: systick.c
    ../drivers/dev_usart/: usart.c
    ../drivers/dev_sg90/: sg90.c
    ../drivers/dev_beep/: beep.c
    ../drivers/dev_adc/: adc.c
    ../drivers/dev_dma/: dma.c
    ../drivers/dev_exti/: exti.c
    ../drivers/dev_iic/: iic.c
    ../drivers/dev_key/: key.c
    ../drivers/dev_seg/: seg.c
    ../drivers/dev_spi/: spi.c
    ../drivers/dev_time/: time.c
    ../drivers/dev_sht20/: sht20.c
    ../drivers/drv_oled/: oled.c
    ../drivers/drv_pd333/: pd333.c
  group cmsis
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group stdlib
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group starup
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
